options:
  parameters:
    author: Jake Sahli
    generate_options: qt_gui
    id: UHF_RX
    output_language: python
    title: UHF RX
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: '2'
  states: {}
- name: agc_integration_const
  id: variable
  parameters:
    value: 2e5
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: M * delta_f
  states: {}
- name: baud_rate
  id: variable
  parameters:
    value: bps * 2 / M
  states: {}
- name: baud_rate_0
  id: variable
  parameters:
    value: bps * 2 / M
  states: {}
- name: baud_rate_display
  id: variable_qtgui_label
  parameters:
    type: real
    value: baud_rate
  states: {}
- name: bb_gain
  id: variable
  parameters:
    value: '16'
  states: {}
- name: bb_gain_display
  id: variable_qtgui_label
  parameters:
    type: int
    value: bb_gain
  states: {}
- name: bps
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: delta_f
  id: variable
  parameters:
    value: 1.1 * bps
  states: {}
- name: demod_offset
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: 413e6
  states: {}
- name: freq_0
  id: variable
  parameters:
    value: 413e6
  states: {}
- name: freq_display
  id: variable_qtgui_label
  parameters:
    type: real
    value: freq
  states: {}
- name: header_bits
  id: variable
  parameters:
    value: '8'
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '16'
  states: {}
- name: if_gain_display
  id: variable_qtgui_label
  parameters:
    type: int
    value: if_gain
  states: {}
- name: packet_bits
  id: variable
  parameters:
    value: '108'
  states: {}
- name: payload_bits
  id: variable
  parameters:
    value: packet_bits - header_bits
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rf_gain_display
  id: variable_qtgui_label
  parameters:
    type: int
    value: rf_gain
  states: {}
- name: samp_per_bit
  id: variable
  parameters:
    value: (int)(samp_rate * (1 / bps))
  states: {}
- name: samp_per_symbol
  id: variable
  parameters:
    value: samp_rate * (1 / baud_rate)
  states: {}
- name: samp_per_symbol_display
  id: variable_qtgui_label
  parameters:
    type: real
    value: samp_per_symbol
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (int) (5e5)
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: delta_f * 3
    audio_stop: delta_f * 7
    chan_rate: samp_rate
    deviation: (delta_f)
    gain: '1.0'
    tau: '0'
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: center_frequency_offset_error
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/tbbg/rx_data
    type: byte
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/tbbg/rx_data_raw
    type: complex
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: int(agc_integration_const)
    type: float
  states: {}
- name: blocks_integrate_xx_0_0
  id: blocks_integrate_xx
  parameters:
    decim: int(agc_integration_const)
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '2000'
    max_iter: '4000'
    scale: 1/2000
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(agc_integration_const)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(agc_integration_const)
    type: float
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: '10'
    type: float
  states: {}
- name: blocks_repeat_0_0_0
  id: blocks_repeat
  parameters:
    interp: '10'
    type: float
  states: {}
- name: blocks_repeat_0_0_1
  id: blocks_repeat
  parameters:
    interp: '10'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: center_frequency_offset_error
  id: parameter
  parameters:
    value: '0.5'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_per_symbol
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      import datetime

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          gain_table = (
               #rf,   if,     bb
               (0,     0,     0),
               (0,     0,     2),
               (0,     0,     4),
               (0,     0,     6),
               (0,     8,     0),
               (0,     8,     2),
               (0,     8,     4),
               (0,     8,     6),
               (0,     8,     8),
               (0,     8,     10),
               (0,     8,     12),
               (0,     8,     14),
               (0,     16,    8),
               (0,     16,    10),
               (0,     16,    12),
               (0,     16,    14),
               (0,     16,    16),
               (0,     16,    18),
               (0,     16,    20),
               (0,     16,    22),
               (0,     24,    16),
               (0,     24,    18),
               (0,     24,    20),
               (0,     24,    22),
               (0,     24,    24),
               (0,     24,    26),
               (0,     24,    28),
               (0,     24,    30),
               (11,    24,    20),
               (11,    24,    22),
               (11,    24,    24),
               (11,    24,    26),
               (11,    24,    28),
               (11,    24,    30),
               (11,    32,    24),
               (11,    32,    26),
               (11,    32,    28),
               (11,    32,    30),
               (11,    32,    32),
               (11,    32,    34),
               (11,    32,    36),
               (11,    32,    38),
               (11,    40,    32),
               (11,    40,    34),
               (11,    40,    36),
               (11,    40,    38),
               (11,    40,    40),
               (11,    40,    42),
               (11,    40,    44),
               (11,    40,    46),
               (11,    40,    48),
               (11,    40,    50),
               (11,    40,    52),
               (11,    40,    54),
               (11,    40,    56),
               (11,    40,    58),
               (11,    40,    60),
               (11,    40,    62),
          )

          log_file = 'gain_log.csv'

          def __init__(self, 
                       max_input_level=0.9, min_input_level=0.1, update_period=0.5, delay_between_settings=0.1, auto_log_time_min=15,
                       ratio_of_freq_change_to_diff=0.9, freq_offset_limit=2e3,
                       callback_rf_gain=None, callback_if_gain=None, callback_bb_gain=None,
                       symbol_delta_f = None, demod_offset = None,
                       callback_set_freq=None, callback_get_freq_0=None,
                       callback_get_freq=None, callback_set_symbol_rate=None, callback_get_symbol_rate_0=None):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Hack RF Setting Adjustment',   # will show up in GRC
                  in_sig=[np.float32, np.float32],
                  out_sig=[]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.max_input_level = max_input_level
              self.min_input_level = min_input_level
              
              self.update_period = update_period
              self.delay_between_settings = delay_between_settings
              
              self.callback_rf_gain = callback_rf_gain
              self.callback_if_gain = callback_if_gain
              self.callback_bb_gain = callback_bb_gain

              self.gain_table_index = 8
              self.log_index = 0
              self.auto_log_time_min = auto_log_time_min
              self.log_index_limit = 60 * auto_log_time_min / update_period

              # if an attribute with the same name as a parameter is found,s
              self.ratio_of_freq_change_to_diff = ratio_of_freq_change_to_diff
              self.freq_offset_limit = freq_offset_limit
              self.demod_offset = demod_offset
              self.symbol_delta_f = symbol_delta_f
              # a callback is registered (properties work, too).
              self.callback_set_freq = callback_set_freq
              self.callback_get_freq_0 = callback_get_freq_0
              self.callback_get_freq = callback_get_freq
              self.callback_set_symbol_rate = callback_set_symbol_rate
              self.callback_get_symbol_rate_0 = callback_get_symbol_rate_0

              import os
              cwd = os.getcwd()
              print(cwd)

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              
              def log():
                  with open(blk.log_file, mode='+a') as f:
                      gain_table_tuple = blk.gain_table[self.gain_table_index]
                      rf_gain = gain_table_tuple[0]
                      if_gain = gain_table_tuple[1]
                      bb_gain = gain_table_tuple[2]
                      freq = self.callback_get_freq()
                      log_msg = ','.join(
                          map(str, 
                              [input_items[0][-1], rf_gain, if_gain, bb_gain, freq]
                          )
                      )
                      print(str(datetime.datetime.now()) + "UTC " + log_msg, file=f)

              if input_items[0][-1] > (self.max_input_level):
                  log()
                  self.decrease_gain()

              if input_items[0][-1] < (self.min_input_level):
                  log()
                  self.increase_gain() 
              
              if self.log_index >= self.log_index_limit:
                  log()
              else:
                  self.log_index += 1
              #output_items[0][:] = input_items[0] * self.example_param
              
              time.sleep(self.delay_between_settings)
              
              self.update_frequency_setting(input_items, log)
              
              time.sleep(self.update_period - self.delay_between_settings)
              return 0 #len(output_items[0])

          def update_frequency_setting(self, input_items, log):
              #input_freq_data = input_items[1][-1] - self.demod_offset
              
              # calculate how much we should adjust the frequency
              diff_in_abs_f = (np.abs(input_items[1][-1]) * self.symbol_delta_f)
              # apply the damping term
              freq_change_to_do = diff_in_abs_f * self.ratio_of_freq_change_to_diff
              
              # calculate which way to move the frequency (inc or dec)
              if freq_change_to_do > 1.5e3 * self.ratio_of_freq_change_to_diff:
                  log()
                  sign = np.sign(input_items[1][-1])
                  freq = self.callback_get_freq()
                  freq += sign * freq_change_to_do
                  
                  # if the proposed change goes past the freq_offset_limit, then set the change to the freq_offset_limit
                  freq_0 = self.callback_get_freq_0()
                  if np.abs(freq - freq_0) > self.freq_offset_limit:
                      freq = self.callback_get_freq_0 + sign * self.freq_offset_limit
                  
                  # update the hackrf freq
                  self.callback_set_freq(freq)

              # update the symbol rate
              #absolute_symbol_rate = self.callback_get_symbol_rate_0()
              #symbol_rate_update = self.callback_get_symbol_rate_0() * (freq / freq_0)
              #self.callback_set_symbol_rate(symbol_rate_update)

          def check_gain_table_index_limits(self):
              if self.gain_table_index < 0:
                  self.gain_table_index = 0
              
              if self.gain_table_index >= len(blk.gain_table):
                  self.gain_table_index = len(blk.gain_table) - 1

          def set_gain_from_gain_table(self):
              gain_table_tuple = blk.gain_table[self.gain_table_index]
              rf_gain = gain_table_tuple[0]
              if_gain = gain_table_tuple[1]
              bb_gain = gain_table_tuple[2]

              self.callback_rf_gain(rf_gain)
              self.callback_if_gain(if_gain)
              self.callback_bb_gain(bb_gain)

          def decrease_gain(self):
              self.gain_table_index -= 1
              self.check_gain_table_index_limits()
              self.set_gain_from_gain_table()

          def increase_gain(self):
              self.gain_table_index += 1
              self.check_gain_table_index_limits()
              self.set_gain_from_gain_table()
    auto_log_time_min: '15'
    callback_bb_gain: self.set_bb_gain
    callback_get_freq: self.get_freq
    callback_get_freq_0: self.get_freq_0
    callback_get_symbol_rate_0: self.get_baud_rate_0
    callback_if_gain: self.set_if_gain
    callback_rf_gain: self.set_rf_gain
    callback_set_freq: self.set_freq
    callback_set_symbol_rate: self.set_baud_rate
    delay_between_settings: '0.25'
    demod_offset: demod_offset
    freq_offset_limit: 15e3
    max_input_level: '0.75'
    min_input_level: '0.1'
    ratio_of_freq_change_to_diff: '0.1'
    symbol_delta_f: delta_f
    update_period: '0.5'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport datetime\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n\n    def __init__(self, \n                update_period=0.5, ratio_of_freq_change_to_diff=0.9, freq_offset_limit=2e3, symbol_delta_f = None,\n                 callback_set_freq=None, callback_get_freq_0=None,\n                 callback_get_freq=None, callback_set_symbol_rate=None, callback_get_symbol_rate_0=None):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=[np.float32],\n            out_sig=[]\n        )\n        # if an attribute with the same name as a parameter is found,\n        self.update_period = update_period\n        self.ratio_of_freq_change_to_diff = ratio_of_freq_change_to_diff\n        self.freq_offset_limit = freq_offset_limit\n        self.symbol_delta_f = symbol_delta_f\n        # a callback is registered (properties work, too).\n        self.callback_set_freq = callback_set_freq\n        self.callback_get_freq_0 = callback_get_freq_0\n        self.callback_get_freq = callback_get_freq\n        self.callback_set_symbol_rate = callback_set_symbol_rate\n        self.callback_get_symbol_rate_0 = callback_get_symbol_rate_0\n        \n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        \n        # calculate how much we should adjust the frequency\n        diff_in_abs_f = (np.abs(input_items[-1][-1]) * self.symbol_delta_f)\n        # apply the damping term\n        freq_change_to_do = diff_in_abs_f * self.ratio_of_freq_change_to_diff\n        \n        # calculate which way to move the frequency (inc or dec)\n        sign = np.sign(input_items[-1][-1])\n        freq = self.callback_get_freq()\n        freq += sign * freq_change_to_do\n        \n        # if the proposed change goes past the freq_offset_limit, then set the change to the freq_offset_limit\n        freq_0 = self.callback_get_freq_0()\n        if np.abs(freq - freq_0) > self.freq_offset_limit:\n            freq = self.callback_get_freq_0 + sign * self.freq_offset_limit\n        \n        # update the hackrf freq\n        self.callback_set_freq(freq)\n\n        # update the symbol rate\n        absolute_symbol_rate = self.callback_get_symbol_rate_0()\n        symbol_rate_update = self.callback_get_symbol_rate_0() * (freq / freq_0)\n        self.callback_set_symbol_rate(symbol_rate_update)\n\n        time.sleep(self.update_period)\n        return 0 #len(output_items[0])\n\n    \n\n\n"
    callback_get_freq: self.get_freq
    callback_get_freq_0: self.get_freq_0
    callback_get_symbol_rate_0: self.get_baud_rate_0
    callback_set_freq: self.set_freq
    callback_set_symbol_rate: self.set_baud_rate
    freq_offset_limit: 5e3
    ratio_of_freq_change_to_diff: '0.1'
    symbol_delta_f: delta_f
    update_period: '0.5'
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 3e3
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"hackrf=0"'
    bb_gain0: bb_gain
    bw0: bandwidth * 10 + demod_offset * 2
    freq0: freq
    gain0: rf_gain
    gain_mode0: 'True'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: 100 * 10
    srate: 10 * samp_rate / baud_rate
    type: float
    update_time: '1'
    ymax: '2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    color2: dark blue
    entags: 'False'
    label1: I
    label2: FM Demod
    label3: Q
    nconnections: '3'
    size: (int) (10 * samp_rate / baud_rate)
    srate: 'samp_rate '
    type: float
    update_time: '1'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: (int) (1e3)
    samp_rate: samp_rate
    sym_rate: baud_rate
    type: fir_filter_fff
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_repeat_0_0, '0']
- [blocks_add_const_vxx_0_0_0, '0', epy_block_0, '1']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_0_0, '2']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_vxx_1_0_0, '0']
- [blocks_integrate_xx_0_0, '0', blocks_multiply_const_vxx_1_0_0_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_sub_xx_0, '1']
- [blocks_multiply_const_vxx_1_0_0, '0', epy_block_0, '0']
- [blocks_multiply_const_vxx_1_0_0_0, '0', blocks_add_const_vxx_0_0_0, '0']
- [blocks_repeat_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_repeat_0_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_repeat_0_0_1, '0', qtgui_time_sink_x_0, '2']
- [blocks_sub_xx_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_repeat_0_0_1, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_moving_average_xx_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_repeat_0_0_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_sub_xx_0, '0']
- [low_pass_filter_0, '0', analog_fm_demod_cf_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_float_0, '0']
- [osmosdr_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [osmosdr_source_0, '0', blocks_file_sink_0_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_integrate_xx_0_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0_0, '1']

metadata:
  file_format: 1
