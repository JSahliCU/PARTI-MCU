options:
  parameters:
    author: Jake Sahli
    generate_options: qt_gui
    id: HF_TUNE
    output_language: python
    title: HF TUNE
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: '2'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: M * delta_f
  states: {}
- name: baud_rate
  id: variable
  parameters:
    value: bps * 2 / M
  states: {}
- name: bb_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: bps
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: delta_f
  id: variable
  parameters:
    value: 1.1 * bps
  states: {}
- name: demod_offset
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: 5.373e6
  states: {}
- name: header_bits
  id: variable
  parameters:
    value: '8'
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '28'
  states: {}
- name: packet_bits
  id: variable
  parameters:
    value: '108'
  states: {}
- name: payload_bits
  id: variable
  parameters:
    value: packet_bits - header_bits
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '14'
  states: {}
- name: samp_per_bit
  id: variable
  parameters:
    value: (int)(samp_rate * (1 / bps))
  states: {}
- name: samp_per_symbol
  id: variable
  parameters:
    value: (int)(samp_rate * (1 / baud_rate))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (int) (2e7)
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: demod_offset / delta_f
    type: float
  states: {}
- name: blocks_vco_c_0_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: (delta_f) * 2 * 3.14159
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=0"'
    bb_gain0: bb_gain
    bw0: demod_offset*2 + delta_f * 10
    freq0: freq
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_vco_c_0_0, '0']
- [blocks_vco_c_0_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
