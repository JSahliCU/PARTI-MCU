options:
  parameters:
    author: Jake Sahli
    generate_options: qt_gui
    id: UHF_TX
    output_language: python
    title: UHF TX
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: '2'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: M * delta_f
  states: {}
- name: baud_rate
  id: variable
  parameters:
    value: bps * 2 / M
  states: {}
- name: bb_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: bps
  id: variable_qtgui_chooser
  parameters:
    label: Symbol Rate
    label0: 1 kbps
    label1: 5 kbps
    label2: 10 kbps
    num_opts: '3'
    option0: '1000'
    option1: '5000'
    option2: '10000'
    orient: Qt.QHBoxLayout
    type: int
    value: '1000'
    widget: radio_buttons
  states: {}
- name: bps
  id: variable
  parameters:
    value: 1e3
  states: {state: disabled}
- name: delta_f
  id: variable
  parameters:
    value: 1.1 * bps
  states: {}
- name: demod_offset
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: 413e6
  states: {}
- name: header_bits
  id: variable
  parameters:
    value: '8'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '28'
    value: '28'
  states: {}
- name: packet_bits
  id: variable
  parameters:
    value: '108'
  states: {}
- name: payload_bits
  id: variable
  parameters:
    value: packet_bits - header_bits
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '14'
    value: '14'
  states: {}
- name: samp_per_bit
  id: variable
  parameters:
    value: (int)(samp_rate * (1 / bps))
  states: {}
- name: samp_per_symbol
  id: variable
  parameters:
    value: (int)(samp_rate * (1 / baud_rate))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (int) (2e6)
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: demod_offset / delta_f
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/tbbg/tx_data
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: (int)(samp_rate * (1 / baud_rate))
    type: byte
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vco_c_0_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: (delta_f) * 2 * 3.14159
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0, 1)
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"hackrf=0"'
    bb_gain0: bb_gain
    bw0: demod_offset*2 + delta_f * 10
    freq0: freq
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: TX_SYMBOLS
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: TX_SYMBOLS
  states: {}

connections:
- [blocks_add_const_vxx_0_0, '0', blocks_vco_c_0_0, '0']
- [blocks_file_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_repeat_0_0, '0']
- [blocks_repeat_0_0, '0', blocks_uchar_to_float_1, '0']
- [blocks_uchar_to_float_1, '0', virtual_sink_0, '0']
- [blocks_vco_c_0_0, '0', osmosdr_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0_0, '0']
- [virtual_source_0, '0', blocks_add_const_vxx_0_0, '0']

metadata:
  file_format: 1
