options:
  parameters:
    author: Jake Sahli
    generate_options: qt_gui
    id: F2SK_Simulation_Loopback_v1e
    output_language: python
    title: 2FSK Simulation Loopback v1e
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: '2'
  states: {}
- name: agc_integration_const
  id: variable
  parameters:
    value: 2e5
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: M * delta_f
  states: {}
- name: baud_rate
  id: variable
  parameters:
    value: bps * 2 / M
  states: {}
- name: bb_gain
  id: variable
  parameters:
    value: '16'
  states: {}
- name: bb_gain_display
  id: variable_qtgui_label
  parameters:
    type: int
    value: bb_gain
  states: {}
- name: bps
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: delta_f
  id: variable
  parameters:
    value: 1.1 * bps
  states: {}
- name: demod_offset
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: 413e6
  states: {}
- name: header_bits
  id: variable
  parameters:
    value: '8'
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '16'
  states: {}
- name: if_gain_display
  id: variable_qtgui_label
  parameters:
    type: int
    value: if_gain
  states: {}
- name: packet_bits
  id: variable
  parameters:
    value: '108'
  states: {}
- name: payload_bits
  id: variable
  parameters:
    value: packet_bits - header_bits
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rf_gain_display
  id: variable_qtgui_label
  parameters:
    type: int
    value: rf_gain
  states: {}
- name: samp_per_bit
  id: variable
  parameters:
    value: (int)(samp_rate * (1 / bps))
  states: {}
- name: samp_per_symbol
  id: variable
  parameters:
    value: (int)(samp_rate * (1 / baud_rate))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (int) (2e6)
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: delta_f * 3
    audio_stop: delta_f * 7
    chan_rate: samp_rate
    deviation: (delta_f)
    gain: '1.0'
    tau: '0'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: center_frequency_offset_error
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: demod_offset / delta_f
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/thatbigblueguy/Insync/jake.sahli@gmail.com/Google Drive/School/PARTI/SDR/HackRF/rx_data
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/thatbigblueguy/Insync/jake.sahli@gmail.com/Google Drive/School/PARTI/SDR/HackRF/tx_data
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: int(agc_integration_const)
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: packet_bits
    max_iter: '4000'
    scale: 1/packet_bits
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(rf_gain/10)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(if_gain/10)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(bb_gain/10)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1*(51) / 10)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(agc_integration_const)
    type: float
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: (int)(samp_rate * (1 / baud_rate))
    type: byte
  states: {}
- name: blocks_repeat_0_0_0
  id: blocks_repeat
  parameters:
    interp: int(agc_integration_const)
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vco_c_0_0
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: (delta_f) * 2 * 3.14159
  states: {}
- name: center_frequency_offset_error
  id: parameter
  parameters:
    value: '0.5'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_per_symbol
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      import datetime

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block

          gain_table = (
               #rf,   if,     bb
               (0,     0,     0),
               (0,     0,     2),
               (0,     0,     4),
               (0,     0,     6),
               (0,     8,     0),
               (0,     8,     2),
               (0,     8,     4),
               (0,     8,     6),
               (0,     8,     8),
               (0,     8,     10),
               (0,     8,     12),
               (0,     8,     14),
               (0,     16,    8),
               (0,     16,    10),
               (0,     16,    12),
               (0,     16,    14),
               (0,     16,    16),
               (0,     16,    18),
               (0,     16,    20),
               (0,     16,    22),
               (0,     24,    16),
               (0,     24,    18),
               (0,     24,    20),
               (0,     24,    22),
               (0,     24,    24),
               (0,     24,    26),
               (0,     24,    28),
               (0,     24,    30),
               (11,    24,    20),
               (11,    24,    22),
               (11,    24,    24),
               (11,    24,    26),
               (11,    24,    28),
               (11,    24,    30),
               (11,    32,    24),
               (11,    32,    26),
               (11,    32,    28),
               (11,    32,    30),
               (11,    32,    32),
               (11,    32,    34),
               (11,    32,    36),
               (11,    32,    38),
               (11,    40,    32),
               (11,    40,    34),
               (11,    40,    36),
               (11,    40,    38),
               (11,    40,    40),
               (11,    40,    42),
               (11,    40,    44),
               (11,    40,    46),
               (11,    40,    48),
               (11,    40,    50),
               (11,    40,    52),
               (11,    40,    54),
               (11,    40,    56),
               (11,    40,    58),
               (11,    40,    60),
               (11,    40,    62),
          )

          log_file = 'gain_log.csv'

          def __init__(self, 
                       goal_input_level=1.0, hysteresis=0.1, update_period=0.1, auto_log_time_min=15,
                       callback_rf_gain=None, callback_if_gain=None, callback_bb_gain=None):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.goal_input_level = goal_input_level
              self.hysteresis = hysteresis
              self.update_period = update_period
              self.callback_rf_gain = callback_rf_gain
              self.callback_if_gain = callback_if_gain
              self.callback_bb_gain = callback_bb_gain

              self.gain_table_index = 8
              self.log_index = 0
              self.auto_log_time_min = auto_log_time_min
              self.log_index_limit = 60 * auto_log_time_min / update_period

              import os
              cwd = os.getcwd()
              print(cwd)

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              
              def log():
                  with open(blk.log_file, mode='+a') as f:
                      gain_table_tuple = blk.gain_table[self.gain_table_index]
                      rf_gain = gain_table_tuple[0]
                      if_gain = gain_table_tuple[1]
                      bb_gain = gain_table_tuple[2]
                      log_msg = ','.join(
                          map(str, 
                              [input_items[-1][-1], rf_gain, if_gain, bb_gain]
                          )
                      )
                      print(str(datetime.datetime.now()) + "UTC " + log_msg, file=f)

              if input_items[-1][-1] > (self.goal_input_level + self.hysteresis/2):
                  log()
                  self.decrease_gain()

              if input_items[-1][-1] < (self.goal_input_level - self.hysteresis/2):
                  log()
                  self.increase_gain() 
              
              if self.log_index >= self.log_index_limit:
                  log()
              else:
                  self.log_index += 1
              #output_items[0][:] = input_items[0] * self.example_param
              
              time.sleep(self.update_period)
              return 0 #len(output_items[0])

          def check_gain_table_index_limits(self):
              if self.gain_table_index < 0:
                  self.gain_table_index = 0
              
              if self.gain_table_index >= len(blk.gain_table):
                  self.gain_table_index = len(blk.gain_table) - 1

          def set_gain_from_gain_table(self):
              gain_table_tuple = blk.gain_table[self.gain_table_index]
              rf_gain = gain_table_tuple[0]
              if_gain = gain_table_tuple[1]
              bb_gain = gain_table_tuple[2]

              self.callback_rf_gain(rf_gain)
              self.callback_if_gain(if_gain)
              self.callback_bb_gain(bb_gain)

          def decrease_gain(self):
              self.gain_table_index -= 1
              self.check_gain_table_index_limits()
              self.set_gain_from_gain_table()

          def increase_gain(self):
              self.gain_table_index += 1
              self.check_gain_table_index_limits()
              self.set_gain_from_gain_table()
    auto_log_time_min: '15'
    callback_bb_gain: self.set_bb_gain
    callback_if_gain: self.set_if_gain
    callback_rf_gain: self.set_rf_gain
    goal_input_level: '1.0'
    hysteresis: '1.2'
    update_period: '0.1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '2'
    size: 1024*100
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: 1024 *100
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: TX_SYMBOLS
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: Base_Band_Waveform
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: TX_SYMBOLS
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Base_Band_Waveform
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_const_vxx_0_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_add_const_vxx_0_0_0, '0', blocks_vco_c_0_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0_0, '0']
- [blocks_complex_to_float_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_1, '1', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_file_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_vxx_1_0_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_sub_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_const_vxx_1, '0', analog_fm_demod_cf_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_complex_to_float_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_multiply_const_vxx_1_0_0, '0', blocks_repeat_0_0_0, '0']
- [blocks_multiply_const_vxx_1_0_0, '0', epy_block_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_repeat_0_0, '0']
- [blocks_repeat_0_0, '0', blocks_throttle_0, '0']
- [blocks_repeat_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_sub_xx_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_throttle_0, '0', blocks_uchar_to_float_1, '0']
- [blocks_uchar_to_float_1, '0', virtual_sink_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_vco_c_0_0, '0', blocks_add_xx_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_moving_average_xx_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_sub_xx_0, '0']
- [virtual_source_0, '0', blocks_add_const_vxx_0_0_0, '0']
- [virtual_source_0_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
