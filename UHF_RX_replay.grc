options:
  parameters:
    author: Jake Sahli
    generate_options: qt_gui
    id: UHF_RX_REPLAY
    output_language: python
    title: UHF RX REPLAY
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: '2'
  states: {}
- name: agc_integration_const
  id: variable
  parameters:
    value: 2e5
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: M * delta_f
  states: {}
- name: baud_rate
  id: variable
  parameters:
    value: bps * 2 / M
  states: {}
- name: bps
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: delta_f
  id: variable
  parameters:
    value: 1.1 * bps
  states: {}
- name: demod_offset
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: 413e6 - 2e3
  states: {}
- name: header_bits
  id: variable
  parameters:
    value: '8'
  states: {}
- name: packet_bits
  id: variable
  parameters:
    value: '108'
  states: {}
- name: payload_bits
  id: variable
  parameters:
    value: packet_bits - header_bits
  states: {}
- name: samp_per_bit
  id: variable
  parameters:
    value: (int)(samp_rate * (1 / bps))
  states: {}
- name: samp_per_symbol
  id: variable
  parameters:
    value: (int)(samp_rate * (1 / baud_rate))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (int) (5e5)
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: delta_f * 3
    audio_stop: delta_f * 7
    chan_rate: samp_rate
    deviation: (delta_f)
    gain: '1.0'
    tau: '0'
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: center_frequency_offset_error
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/tbbg/rx_data
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/tbbg/rx_data_rawUHF240125T133323
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '2000'
    max_iter: '4000'
    scale: 1/2000
    type: float
  states: {}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: '10'
    type: float
  states: {}
- name: blocks_repeat_0_0_0
  id: blocks_repeat
  parameters:
    interp: '10'
    type: float
  states: {}
- name: blocks_repeat_0_0_1
  id: blocks_repeat
  parameters:
    interp: '10'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: center_frequency_offset_error
  id: parameter
  parameters:
    value: '0.5'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samp_per_symbol
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: ff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 3e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: 100 * 10
    srate: 10 * samp_rate / baud_rate
    type: float
    update_time: '1'
    ymax: '2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    nconnections: '3'
    size: (int) (10 * samp_rate / baud_rate)
    srate: 'samp_rate '
    type: float
    update_time: '1'
    ymax: '2'
    ymin: '-2'
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_fm_demod_cf_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_add_const_vxx_0_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_repeat_0_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_time_sink_x_0_0, '2']
- [blocks_file_source_0, '0', low_pass_filter_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_sub_xx_0, '1']
- [blocks_repeat_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_repeat_0_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_repeat_0_0_1, '0', qtgui_time_sink_x_0, '2']
- [blocks_sub_xx_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_repeat_0_0_1, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_moving_average_xx_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_repeat_0_0_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_sub_xx_0, '0']
- [low_pass_filter_0, '0', analog_fm_demod_cf_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
